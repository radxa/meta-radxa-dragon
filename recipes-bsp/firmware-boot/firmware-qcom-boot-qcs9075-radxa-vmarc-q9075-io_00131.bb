require firmware-qcom-boot-qcs9100.inc

DESCRIPTION = "QCOM NHLOS Firmware for Radxa VMARC-Q9075 IO board"
FW_ARTIFACTORY = "dl.radxa.com/users/dev/radxa-dragon/qli-2.0/radxa-vmarc-q9075-io/firmware-boot"
SRC_URI[bootbinaries.sha256sum] = "1e50cc3635e454e357c64939c61170ad02239e3338389c3ae05978a1e5fd9aba"
